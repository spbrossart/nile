FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://remove-pcie-xilinx-cpm.cfg"
